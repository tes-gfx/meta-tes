FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://0001_add_aes128_cbc_to_ciphers.patch"
