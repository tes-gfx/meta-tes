#UBOOT_REPO = "git://github.com/tes-gfx/u-boot-socfpga.git"
#UBOOT_REPO:tesintern = "git:////home/hh04074/projects/ip/linux_agilex/yocto_build/repos/u-boot-socfpga"
#UBOOT_PROT:tesintern = "file"

UBOOT_REPO = "git://github.com/ArrowElectronics/u-boot-socfpga.git"
UBOOT_BRANCH = "socfpga_agilex5-ES_RC"

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

#UBOOT_VERSION = "v2023.10_tes"

SRCREV = "a36b659c3efa1c7cc77e897ce486b2280ade10be"
