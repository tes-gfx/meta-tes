inherit populate_slimsdk_base

addtask populate_slimsdk after do_install before do_build

