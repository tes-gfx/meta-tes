# Comment out since it seems to be broken in the current meta-qt5
#PACKAGECONFIG += "examples"
